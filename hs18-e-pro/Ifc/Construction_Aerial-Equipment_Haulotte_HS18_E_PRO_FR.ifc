Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-10-13T08:29:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 13 08:29:26 2021 * Host: DESKTOP-0BIHJ9F * Database: C:\Users\BIMOBJ~1\AppData\Local\Temp\{B100892F-D598-4CE5-8983-89AE424E1841}\ifc * Database version: 5507 * Database creation date: Wed Oct 13 08:29:20 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 13 08:29:21 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 13 08:29:21 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: HS18 E PRO, Construction_Aerial-Equipment_Haulotte_HS18_E_PRO_FR:HS18 E PRO:220759
In: Level 1
Type - Material: Haulotte - Metal - Black RAL 9017, Haulotte - Metal - Grey RAL 7016, Haulotte - Metal - Yellow RAL 1006, Haulotte - Metal - White
Type - Data - Batteries: C5 : 357 Ah, C20 : 435 Ah; Capacité Maximum – Extérieur: 750 kg/ 1653.46 lb; Capacité Maximum - Intérieur: 750 kg/ 1653.46 lb; Capacité Réservoir Huile Hydraulique: 76 L; Devers: 5°/2°; Empattement: 2.755/ 108.46 in 2.755/ 108.46 in; Garde au Sol: 0.307 m/ 12.09 in; Garde au Sol - Potholes Baissés: 0.597 m/ 23.5 in; Hauteur Maximale de Translation: 11 m/ 433.07 in; Hauteur Plateforme: 16 m/ 629.92 in; Hauteur Repliée: 3.15 m/ 124.02 in; Hauteur Travail: 18 m/708.66 in; Largeur Hors Tout: 2.3 m/ 90.55 in; Largeur Plateforme: 1.89 m/ 74.41 in; Longueur Extension: 0.98 m/ 38.58 in; Longueur Hors Tout: 4.4 m/173.43 in; Longueur Plateforme: 3.93 m/ 154.72 in; Longueur Plateforme Étendue: 5.8 m/ 228.35 in; Masse Machine (CE): 8048 kg/ 17742.8 lb; Pente Maximum: 40%; Pneus: 830x285 mm/ 32.68x11.22 in; Pression Max au Sol: 6.74 daN/cm²; Rayon de Braquage Exterieur: 6.75 m/ 265.75 in; Rayon de Braquage Interieur: 4.35 m/ 171.26 in; Vitesse de Translation: 5 km/h/ 3.11 mph
Type - General - Design country: France; Edition number: 1; Manufacturer name: Haulotte; Product name: HS 15-18 E PRO; Product SKU: hs-15-18-e-pro
Type - Identity Data - Description: Electric rough terrain scissor lift; Manufacturer: Haulotte; Model: HS18 E PRO; OmniClass Number: 23.23.13.11.19; OmniClass Title: Platform Lifts; Product data url: https://bimobject.com/haulotte/product/hs-15-18-e-pro; Product url: https://www.haulotte.co.uk/product/hs18-e-pro-0; Type Name: HS18 E PRO; URL: https://www.haulotte.co.uk/product/hs18-e-pro-0
Type - Materials and Finishes - Logo material: Haulotte - Metal - Black RAL 9017
Type - Other - Category: Specialty Equipment; Family Name: Construction_Aerial-Equipment_Haulotte_HS18_E_PRO_FR
Pset_BuildingElementProxyCommon - Reference: HS18 E PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - Abaque de Travail: no; Extension Plateforme Arrière: 1000 mm; Extension Plateforme Avant: 1000 mm; Hauteur de Plateforme: 16000 mm; Pelles de soutien extraites: no; Rayon de Braquage Exterieur: no; Zone de Travail: no
Dimensions - Area: 138.31 m2; Volume: 41.3248 m3
Graphics - Marque: yes
Other - Family: Construction_Aerial-Equipment_Haulotte_HS18_E_PRO_FR: HS18 E PRO; Family and Type: Construction_Aerial-Equipment_Haulotte_HS18_E_PRO_FR: HS18 E PRO; Type: Construction_Aerial-Equipment_Haulotte_HS18_E_PRO_FR: HS18 E PRO; Type Id: Construction_Aerial-Equipment_Haulotte_HS18_E_PRO_FR: HS18 E PRO; zHeight: 15289.3 mm; zL: 787.892 mm; zMaxHeightCTRL: 16000 mm
Phasing - Phase Created: New Construction
